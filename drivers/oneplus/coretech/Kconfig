## drivers/oneplus/coretech/Kconfig
```kconfig
config HOUSTON
	default y
	bool "to collect system-wide and pmu data"
	help
	 Realtime temperature monitor
```
